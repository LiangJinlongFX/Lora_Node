# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,PLATFORM=SX12xxEiger
  c include: ..\Common;..\CORE;..\STM32F1_LIB\inc;..\SYSTEM;..\BSP_USER\LED;..\BSP_USER\BME280;..\BSP_USER\SPI;..\SX1278\radio;..\SX1278\platform\sx12xxEiger;..\SX1278\platform;..\BSP_USER\IIC;..\BSP_USER\BH1750;..\BSP_USER\ADC;..\SX1278;..\BSP_USER\IIC_2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/: main.c stm32f10x_it.c system_stm32f10x.c
  group BSP_USER
    ../BSP_USER/LED/: led.c
    ../BSP_USER/BME280/: bme280.c bme280_app.c
    ../BSP_USER/IIC/: myiic.c
    ../BSP_USER/BH1750/: bh1750.c
    ../BSP_USER/ADC/: adc.c
    ../SX1278/: lora_network_node.c
    ../BSP_USER/IIC_2/: my_iic2.c
  group COMMON
    ../Common/: delay.c sys.c usart1.c
  group STM32F1_LIB
    ../STM32F1_LIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_adc.c
  group Radio
    ../SX1278/radio/: radio.c sx1276.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276-Fsk.c sx1276-FskMisc.c
  group SX12xxEiger
    ../SX1278/platform/sx12xxEiger/: fifo.c spi.c sx1276-Hal.c sx12xxEiger.c
software components: CMSIS:CORE 5.0.2
